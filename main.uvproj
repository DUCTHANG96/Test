# Keil uVision project main.uvproj, settings and files
target CONTRONL_PANEL (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: CONTRONL_PALEN +hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./Code/: main.c
  group Common
    ./INCLUDE/: Delay.c
